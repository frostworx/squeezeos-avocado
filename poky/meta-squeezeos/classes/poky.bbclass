MIRRORS_append () {
ftp://.*/.*    ENTER_SRC_MIRROR/
http://.*/.*   ENTER_SRC_MIRROR/
https://.*/.*   ENTER_SRC_MIRROR/
}
